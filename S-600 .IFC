Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: 00 6.0000_20260210_BIM SIN TORNILLOS IFC V1.IFC
Time: 2026-02-18T11:43:13
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 0.1150_RAL7024 - Tornillo DIN-933 A-4 M10x60 Lacado oscuro_20260210_BIM_Default
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 0.1160_RAL7024 - Tornillo DIN-933 DP M8x20 Lacado oscuro_20260210_BIM_Default (2)
In: Default Storey
Material: AISI 1010 Barra de acero laminada en caliente

# IfcBuildingElementProxy: 0.1210 - Tornillo DIN-6912 A-4 M5x8_20260210_BIM_Default (4)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 0.1305_RAL9006 - Tornillo ISO-7380 A-4 M8x12 Lacado claro_20260210_BIM_Default (10)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 0.1315_RAL9006 - Tornillo ISO-7380 A-4 M8x20 TX40_20260210_BIM (2)
In: Default Storey
Material: AISI 316 Barra de acero inoxidable

# IfcBuildingElementProxy: 0.1440 - Arandela DIN-125 DP M10_20260210_BIM_Default (3)
In: Default Storey
Material: AISI 2205 Barra de acero inoxidable

# IfcBuildingElementProxy: 0.1485 - Arandela groover DIN-127 DP M10_20260210_BIM_Default
In: Default Storey
Material: AISI 2205 Barra de acero inoxidable

# IfcBuildingElementProxy: 0.3600_20260210_BIM_Compras
In: Default Storey
Material: goma para juntas

# IfcBuildingElementProxy: 0.3605_20260210_BIM_Default (2)
In: Default Storey
Material: Nailon 101

# IfcBuildingElementProxy: 0.5025_20260210_BIM
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 0.5605_20260210_BIM_Compras
In: Default Storey
Material: Nailon PA66

# IfcBuildingElementProxy: 6.1605_20260210_BIM
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 6.1630_20260210_BIM
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 6.2120_20260210_BIM
In: Default Storey
Material: AISI 316 Chapa de acero inoxidable

# IfcBuildingElementProxy: 6.2125_20260210_BIM
In: Default Storey
Material: AISI 316 Chapa de acero inoxidable

# IfcBuildingElementProxy: 6.2130_20260210_BIM
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 6.2505_20260210_BIM (2)
In: Default Storey
Material: AISI 316 Chapa de acero inoxidable

# IfcBuildingElementProxy: 6.3020_20260210_BIM
In: Default Storey
Material: AISI 316 Barra de acero inoxidable

# IfcBuildingElementProxy: 6.3025_20260210_BIM
In: Default Storey
Material: POM Acetal Copolymer

# IfcBuildingElementProxy: 6.3030_20260210_BIM (2)
In: Default Storey
Material: POM Acetal Copolymer

# IfcBuildingElementProxy: 6.6010_20260210_BIM (2)
In: Default Storey
Material: AISI 316 Barra de acero inoxidable

# IfcBuildingElementProxy: 6.6020_20260210_BIM
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: 6.6105_20260210_BIM
In: Default Storey
Material: Material <sin especificar>

# IfcBuildingElementProxy: Carcasa silla
In: Default Storey
Material: ABS
